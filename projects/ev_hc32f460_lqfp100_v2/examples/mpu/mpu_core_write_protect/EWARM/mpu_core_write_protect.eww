<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mpu_core_write_protect.ewp</path>
  </project>
  <batchBuild/>
</workspace>


